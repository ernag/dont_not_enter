# IAR project SPPLEDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SUPPORT_LOW_ENERGY__; DEBUG_ENABLED
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\Platform; ..\..\..\..\Bluetopia\btpskrnl; ..\..\..\..\Bluetopia\btpsvend; ..\..\..\..\Bluetopia\hcitrans; ..\..\..\..\Bluetopia\include; ..\..\..\..\Bluetopia\profiles\GAPS\include; ..\..\..\..\Bluetopia\profiles\GATT\include; $_FREESCALE_MQX_PATH_$\lib\twrk60n512.iar\debug; $_FREESCALE_MQX_PATH_$\lib\twrk60n512.iar\debug\bsp; $_FREESCALE_MQX_PATH_$\lib\twrk60n512.iar\debug\bsp\Generated_Code; $_FREESCALE_MQX_PATH_$\lib\twrk60n512.iar\debug\psp
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SPPLEDemo.srec
  ILINK.IlinkOutputFile: SPPLEDemo.out
  ILINK.IlinkIcfFile: $_FREESCALE_MQX_PATH_$\lib\twrk60n512.iar\debug\bsp\intflash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\Bluetopia\lib\Bluetopia.a; ..\..\..\..\Bluetopia\profiles\GAPS\lib\SS1BTGAP.a; ..\..\..\..\Bluetopia\profiles\GATT\lib\SS1BTGAT.a; $_FREESCALE_MQX_PATH_$\lib\twrk60n512.iar\debug\bsp\bsp.a; $_FREESCALE_MQX_PATH_$\lib\twrk60n512.iar\debug\psp\psp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  ICCARM.CCDefines: NDEBUG; __SUPPORT_LOW_ENERGY__
  ICCARM.CCIncludePath2: ..; ..\..\..\Platform; ..\..\..\..\Bluetopia\btpskrnl; ..\..\..\..\Bluetopia\btpsvend; ..\..\..\..\Bluetopia\hcitrans; ..\..\..\..\Bluetopia\include; ..\..\..\..\Bluetopia\profiles\GDIS\include; ..\..\..\..\Bluetopia\profiles\GAPS\include; ..\..\..\..\Bluetopia\profiles\GATT\include; $_FREESCALE_MQX_PATH_$\lib\twrk60n512.iar\debug; $_FREESCALE_MQX_PATH_$\lib\twrk60n512.iar\debug\bsp; $_FREESCALE_MQX_PATH_$\lib\twrk60n512.iar\debug\bsp\Generated_Code; $_FREESCALE_MQX_PATH_$\lib\twrk60n512.iar\debug\psp
  ICCARM.CCOptLevel: 3
  group (top)
    ../: SPPLEDemo.c
  group Bluetopia
    ../../../../Bluetopia/btpskrnl/: BTPSKRNL.c
    ../../../../Bluetopia/btpsvend/: BTPSVEND.c
    ../../../../Bluetopia/hcitrans/: HCITRANS.c
  group Platform
    ../../../Platform/: HAL.c
