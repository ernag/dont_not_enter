# IAR project SPPDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG_ENABLED
  ICCARM.CCDiagSuppress: Pa050,Pe186
  ICCARM.CCIncludePath2: ..; ..\..\..\Platform; ..\..\..\..\Bluetopia\btpskrnl; ..\..\..\..\Bluetopia\btpsvend; ..\..\..\..\Bluetopia\hcitrans; ..\..\..\..\Bluetopia\include; $_FREESCALE_MQX_PATH_$\lib\twrk60n512.iar\debug; $_FREESCALE_MQX_PATH_$\lib\twrk60n512.iar\debug\bsp; $_FREESCALE_MQX_PATH_$\lib\twrk60n512.iar\debug\bsp\Generated_Code; $_FREESCALE_MQX_PATH_$\lib\twrk60n512.iar\debug\psp
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SPPDemo.srec
  ILINK.IlinkOutputFile: SPPDemo.out
  ILINK.IlinkIcfFile: $_FREESCALE_MQX_PATH_$\lib\twrk60n512.iar\debug\bsp\intflash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\Bluetopia\lib\Bluetopia.a; $_FREESCALE_MQX_PATH_$\lib\twrk60n512.iar\debug\bsp\bsp.a; $_FREESCALE_MQX_PATH_$\lib\twrk60n512.iar\debug\psp\psp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..; ..\..\..\Platform; ..\..\..\..\Bluetopia\btpskrnl; ..\..\..\..\Bluetopia\btpsvend; ..\..\..\..\Bluetopia\hcitrans; ..\..\..\..\Bluetopia\include; $_FREESCALE_MQX_PATH_$\lib\twrk60n512.iar\release; $_FREESCALE_MQX_PATH_$\lib\twrk60n512.iar\release\bsp; $_FREESCALE_MQX_PATH_$\lib\twrk60n512.iar\release\bsp\Generated_Code; $_FREESCALE_MQX_PATH_$\lib\twrk60n512.iar\release\psp
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ILINK.IlinkIcfFile: $_FREESCALE_MQX_PATH_$\lib\twrk60n512.iar\release\bsp\intflash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\Bluetopia\lib\Bluetopia.a; $_FREESCALE_MQX_PATH_$\lib\twrk60n512.iar\release\bsp\bsp.a; $_FREESCALE_MQX_PATH_$\lib\twrk60n512.iar\release\psp\psp.a
  group (top)
    ../: SPPDemo.c
  group Bluetopia
    ../../../../Bluetopia/btpskrnl/: BTPSKRNL.c
    ../../../../Bluetopia/btpsvend/: BTPSVEND.c
    ../../../../Bluetopia/hcitrans/: HCITRANS.c
  group Platform
    ../../../Platform/: HAL.c
