# IAR project ISPPDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG_ENABLED
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\Platform; ..\..\..\..\Bluetopia\btpskrnl; ..\..\..\..\Bluetopia\btpsvend; ..\..\..\..\Bluetopia\hcitrans; ..\..\..\..\Bluetopia\iacptran; ..\..\..\..\Bluetopia\include; ..\..\..\..\Bluetopia\profiles\ISPP\include; $_FREESCALE_MQX_PATH_$\lib\twrk60n512.iar\debug; $_FREESCALE_MQX_PATH_$\lib\twrk60n512.iar\debug\bsp; $_FREESCALE_MQX_PATH_$\lib\twrk60n512.iar\debug\bsp\Generated_Code; $_FREESCALE_MQX_PATH_$\lib\twrk60n512.iar\debug\psp
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ISPPDemo.srec
  ILINK.IlinkOutputFile: ISPPDemo.out
  ILINK.IlinkIcfFile: $_FREESCALE_MQX_PATH_$\lib\twrk60n512.iar\debug\bsp\intflash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\Bluetopia\lib\Bluetopia.a; ..\..\..\..\Bluetopia\profiles\ISPP\lib\SS1BTISP.a; $_FREESCALE_MQX_PATH_$\lib\twrk60n512.iar\debug\bsp\bsp.a; $_FREESCALE_MQX_PATH_$\lib\twrk60n512.iar\debug\psp\psp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: ISPPDemo.c
  group Bluetopia
    ../../../../Bluetopia/btpskrnl/: BTPSKRNL.c
    ../../../../Bluetopia/btpsvend/: BTPSVEND.c
    ../../../../Bluetopia/hcitrans/: HCITRANS.c
    ../../../../Bluetopia/iacptran/: IACPTRAN.c
  group Platform
    ../../../Platform/: HAL.c
