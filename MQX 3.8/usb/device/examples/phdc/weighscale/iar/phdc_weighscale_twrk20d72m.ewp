# IAR project phdc_weighscale_twrk20d72m.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK20DX256Zxxx10 Freescale MK20DX256Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pa082,Pe186
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\lib\twrk20d72m.iar\bsp; ..\..\..\..\..\..\lib\twrk20d72m.iar\psp; ..\..\..\..\..\..\lib\twrk20d72m.iar\bsp\Generated_Code; ..\..\..\..\..\..\lib\twrk20d72m.iar; ..\..\..\..\..\..\lib\twrk20d72m.iar\usb\device; ..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: twrk20d72m.srec
  ILINK.IlinkOutputFile: twrk20d72m.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\lib\twrk20d72m.iar\bsp\intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
configuration Int Ram Debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\lib\twrk20d72m.iar\bsp\ram.icf
configuration Int Ram Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\lib\twrk20d72m.iar\bsp\ram.icf
  group MQX Libraries
    ../../../../../../lib/twrk20d72m.iar/bsp/: bsp_twrk20d72m_d.a bsp_twrk20d72m.a
    ../../../../../../lib/twrk20d72m.iar/psp/: psp_twrk20d72m_d.a psp_twrk20d72m.a
    ../../../../../../lib/twrk20d72m.iar/: twrk20d72m_lib.txt
  group USB Device Libraries
    ../../../../../../lib/twrk20d72m.iar/usb/device/: usb_ddk_twrk20d72m_d.a usb_ddk_twrk20d72m.a
  group Source
    ../: ieee11073_nom_codes.h ieee11073_phd_types.h phd_com_model.c phd_com_model.h usb_descriptor.c usb_descriptor.h weighscale.c weighscale.h
