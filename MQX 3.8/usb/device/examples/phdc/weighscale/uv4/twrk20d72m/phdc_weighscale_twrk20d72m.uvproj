# Keil uVision project phdc_weighscale_twrk20d72m.uvproj, settings and files
target phdc_weighscale Int Flash Debug (ARM-ADS)
  device: MK20DX256xxx10 Freescale Semiconductor
  cpu: IRAM(0x1FFF8000-0x1FFFFFFF) IRAM2(0x20000000-0x20007FFF) IROM(0x0-0x3FFFF) IROM2(0x10000000-0x1003FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: phdc_weighscale_intflash_d +hex
  c flags: Optim=1 OneElfS=1
  c include: ..\..\..\..\..\..\..\lib\twrk20d72m.uv4\bsp;..\..\..\..\..\..\..\lib\twrk20d72m.uv4\psp;..\..\..\..\..\..\..\lib\twrk20d72m.uv4;..\..\..\source\include;..\..\..\source\psp\cortex;..\..;..\..\..\..\..\..\..\lib\twrk20d72m.uv4;..\..\..\..\..\..\..\lib\twrk20d72m.uv4\bsp\Generated_Code;..\..\..\..\..\..\..\lib\twrk20d72m.uv4\psp;..\..\..\..\..\..\..\lib\twrk20d72m.uv4\bsp;..\..\..\..\..\..\..\lib\twrk20d72m.uv4\usb\device
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\..\..\..\..\lib\twrk20d72m.uv4\bsp\intflash.scf
  link misc: ..\..\..\..\..\..\..\lib\twrk20d72m.uv4\bsp\bsp_twrk20d72m_d.lib(linker_symbols.o)
..\..\..\..\..\..\..\lib\twrk20d72m.uv4\bsp\bsp_twrk20d72m_d.lib(vectors.o)
--keep linker_symbols.o(KERNEL_DATA_START)
--keep linker_symbols.o(KERNEL_DATA_END)
--keep linker_symbols.o(BOOT_STACK)
--keep vectors.o(.vectors_rom)
--diag_suppress=L6314W
  group MQX Libraries
    ../../../../../../../lib/twrk20d72m.uv4/: twrk20d72m_lib.txt
    ../../../../../../../lib/twrk20d72m.uv4/psp/: psp_twrk20d72m.lib psp_twrk20d72m_d.lib
    ../../../../../../../lib/twrk20d72m.uv4/bsp/: bsp_twrk20d72m.lib bsp_twrk20d72m_d.lib
  group Source
    ../../../../../../../usb/device/examples/phdc/weighscale/: weighscale.h weighscale.c usb_descriptor.h usb_descriptor.c phd_com_model.h phd_com_model.c ieee11073_phd_types.h ieee11073_nom_codes.h
  group USB Device Libraries
    ../../../../../../../lib/twrk20d72m.uv4/usb/device/: usb_ddk_twrk20d72m.lib usb_ddk_twrk20d72m_d.lib
target phdc_weighscale Int Flash Release (ARM-ADS)
  device: MK20DX256xxx10 Freescale Semiconductor
  cpu: as above
  output: phdc_weighscale_inflash +hex
  c flags: Optim=1 OneElfS=1
  c include: as above
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\..\..\..\..\lib\twrk20d72m.uv4\bsp\intflash.scf
  link misc: ..\..\..\..\..\..\..\lib\twrk20d72m.uv4\bsp\bsp_twrk20d72m.lib(linker_symbols.o)
..\..\..\..\..\..\..\lib\twrk20d72m.uv4\bsp\bsp_twrk20d72m.lib(vectors.o)
--keep linker_symbols.o(KERNEL_DATA_START)
--keep linker_symbols.o(KERNEL_DATA_END)
--keep linker_symbols.o(BOOT_STACK)
--keep vectors.o(.vectors_rom)
--diag_suppress=L6314W
