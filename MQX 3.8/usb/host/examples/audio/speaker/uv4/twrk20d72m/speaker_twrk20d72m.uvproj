# Keil uVision project speaker_twrk20d72m.uvproj, settings and files
target speaker Int Flash Debug (ARM-ADS)
  device: MK20DX256xxx10 Freescale Semiconductor
  cpu: IRAM(0x1FFF8000-0x1FFFFFFF) IRAM2(0x20000000-0x20007FFF) IROM(0x0-0x3FFFF) IROM2(0x10000000-0x1003FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: speaker_intflash_d +hex
  c flags: Optim=1 OneElfS=1
  c include: ..\..\..\..\..\..\..\lib\twrk20d72m.uv4\bsp;..\..\..\..\..\..\..\lib\twrk20d72m.uv4\psp;..\..\..\..\..\..\..\lib\twrk20d72m.uv4;..\..\..\source\include;..\..\..\source\psp\cortex;..\..;..\..\..\..\..\..\..\lib\twrk20d72m.uv4;..\..\..\..\..\..\..\lib\twrk20d72m.uv4\bsp\Generated_Code;..\..\..\..\..\..\..\lib\twrk20d72m.uv4\psp;..\..\..\..\..\..\..\lib\twrk20d72m.uv4\bsp;..\..\..\..\..\..\..\lib\twrk20d72m.uv4\mfs;..\..\..\..\..\..\..\lib\twrk20d72m.uv4\shell;..\..\..\..\..\..\..\lib\twrk20d72m.uv4\usb\host
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\..\..\..\..\lib\twrk20d72m.uv4\bsp\intflash.scf
  link misc: ..\..\..\..\..\..\..\lib\twrk20d72m.uv4\bsp\bsp_twrk20d72m_d.lib(linker_symbols.o)
..\..\..\..\..\..\..\lib\twrk20d72m.uv4\bsp\bsp_twrk20d72m_d.lib(vectors.o)
--keep linker_symbols.o(KERNEL_DATA_START)
--keep linker_symbols.o(KERNEL_DATA_END)
--keep linker_symbols.o(BOOT_STACK)
--keep vectors.o(.vectors_rom)
--diag_suppress=L6314W
  group MQX Libraries
    ../../../../../../../lib/twrk20d72m.uv4/: twrk20d72m_lib.txt
    ../../../../../../../lib/twrk20d72m.uv4/psp/: psp_twrk20d72m.lib psp_twrk20d72m_d.lib
    ../../../../../../../lib/twrk20d72m.uv4/bsp/: bsp_twrk20d72m.lib bsp_twrk20d72m_d.lib
  group Source
    ../../../../../../../usb/host/examples/audio/speaker/: wav.h wav.c usb_classes.h sh_audio.h sh_audio.c audio_timer.h audio_timer.c audio_speaker.h audio_speaker.c
  group MFS Libraries
    ../../../../../../../lib/twrk20d72m.uv4/mfs/: mfs_twrk20d72m.lib mfs_twrk20d72m_d.lib
  group USB Host Libraries
    ../../../../../../../lib/twrk20d72m.uv4/usb/host/: usb_classes.c usb_hdk_twrk20d72m.lib usb_hdk_twrk20d72m_d.lib
  group Shell Libraries
    ../../../../../../../lib/twrk20d72m.uv4/shell/: shell_twrk20d72m.lib shell_twrk20d72m_d.lib
target speaker Int Flash Release (ARM-ADS)
  device: MK20DX256xxx10 Freescale Semiconductor
  cpu: as above
  output: speaker_inflash +hex
  c flags: Optim=1 OneElfS=1
  c include: as above
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\..\..\..\..\lib\twrk20d72m.uv4\bsp\intflash.scf
  link misc: ..\..\..\..\..\..\..\lib\twrk20d72m.uv4\bsp\bsp_twrk20d72m.lib(linker_symbols.o)
..\..\..\..\..\..\..\lib\twrk20d72m.uv4\bsp\bsp_twrk20d72m.lib(vectors.o)
--keep linker_symbols.o(KERNEL_DATA_START)
--keep linker_symbols.o(KERNEL_DATA_END)
--keep linker_symbols.o(BOOT_STACK)
--keep vectors.o(.vectors_rom)
--diag_suppress=L6314W
