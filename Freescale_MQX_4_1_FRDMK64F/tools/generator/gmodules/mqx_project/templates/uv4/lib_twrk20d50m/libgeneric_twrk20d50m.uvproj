# Keil uVision project libgeneric_twrk20d50m.uvproj, settings and files
target Debug (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: IRAM(0x1FFFE000-0x1FFFFFFF) IRAM2(0x20000000-0x20001FFF) IROM(0x0-0x1FFFF) IROM2(0x10000000-0x10007FFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: XXXlibrarynameXXX_twrk20d50m_d (library)
  AfterMake: "..\bat\XXXlibrarynameXXX_twrk20d50m.bat" "..\..\..\lib\twrk20d50m.uv4\XXXlibrarynameXXX" uv4 debug twrk20d50m
  c flags: Optim=1 OneElfS=1
  c define: MQX_DISABLE_CONFIG_CHECK, _DEBUG
  c misc: --c99
  asm misc: --cpreproc --diag_suppress=1609
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: ..\..\..\lib\twrk20d50m.uv4\mqx\intflash.scf
target Release (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: as above
  output: XXXlibrarynameXXX_twrk20d50m (library)
  AfterMake: "..\bat\XXXlibrarynameXXX_twrk20d50m.bat" "..\..\..\lib\twrk20d50m.uv4\XXXlibrarynameXXX" uv4 release twrk20d50m
  c flags: Optim=4 OneElfS=1
  c define: MQX_DISABLE_CONFIG_CHECK, NDEBUG
  c misc: --c99
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: ..\..\..\lib\twrk20d50m.uv4\mqx\intflash.scf
