# Keil uVision project twrk21d50m.uvproj, settings and files
target Int Flash Debug (ARM-ADS)
  device: MK20DN512xxx10 Freescale Semiconductor
  cpu: IRAM(0x1FFFE000-0x1FFFFFFF) IRAM2(0x20000000-0x20001FFF) IROM(0x0-0x1FFFF) IROM2(0x10000000-0x10007FFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: XXXappnameXXX_intflash_d +hex
  c flags: Optim=1 OneElfS=1
  c misc: --c99
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x08000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\..\lib\twrk21d50m.uv4\bsp\intflash.scf
  link misc: ../../../../lib/twrk21d50m.uv4/debug/psp/psp.lib(linker_symbols.o)
../../../../lib/twrk21d50m.uv4/debug/bsp/bsp.lib(vectors.o)
--keep linker_symbols.o(KERNEL_DATA_START)
--keep linker_symbols.o(KERNEL_DATA_END)
--keep linker_symbols.o(BOOT_STACK)
--keep vectors.o(.vectors_rom)
--diag_suppress=L6314W
target Int Flash Release (ARM-ADS)
  device: MK20DN512xxx10 Freescale Semiconductor
  cpu: IRAM(0x1FFFE000-0x1FFFFFFF) IRAM2(0x20000000-0x20001FFF) IROM(0x0-0x1FFFF) IROM2(0x10000000-0x10007FFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: XXXappnameXXX_inflash +hex
  c flags: Optim=4 OneElfS=1
  c misc: --c99
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x08000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: ..\..\..\..\lib\twrk21d50m.uv4\bsp\intflash.scf
  link misc: ../../../../lib/twrk21d50m.uv4/release/psp/psp.lib(linker_symbols.o)
../../../../lib/twrk21d50m.uv4/release/bsp/bsp.lib(vectors.o)
--keep linker_symbols.o(KERNEL_DATA_START)
--keep linker_symbols.o(KERNEL_DATA_END)
--keep linker_symbols.o(BOOT_STACK)
--keep vectors.o(.vectors_rom)
--diag_suppress=L6314W
