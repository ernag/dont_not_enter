<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\vybrid_autoevb_a5.ewp</path>
  </project>
  <batchBuild/>
</workspace>


